# Keil uVision project Ladoga_mod5 .uvproj, settings and files
target Ladoga_mod5 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Zar_IP +hex
  c flags: Optim=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL
  c misc: --diag_suppress 188 --diag_suppress 111
  c include: .\Main;.\Protocol;.\Xtea\include;.\Tasks\include;.\Sys_Files\include;.\Work_Files\include;.\STM32F10x_StdPeriph_Driver\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\Obj\Zar_IP.sct
  group Main
    ./Main/: main.c
  group Tasks
    ./Tasks/: time_counter.c brshs_handler.c touch_memory.c device_handler.c modem_handler.c indication_manager.c za_protocol_handler.c
  group Startup
    ./Startup/: startup_stm32f10x_cl.s
  group Sys_Files
    ./Sys_Files/: core_cm3.c stm32f10x_it.c system_setup.c RTX_Conf_CM.c system_stm32f10x_cl.c
  group Work_Files
    ./Work_Files/: slre.c itoa.c md5.c flash.c usart.c crc16.c xtea32m.c keyboard.c serial_number.c
  group STM32F10x_StdPeriph_Driver
    ./STM32F10x_StdPeriph_Driver/: misc.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_pwr.c stm32f10x_bkp.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_flash.c stm32f10x_usart.c
